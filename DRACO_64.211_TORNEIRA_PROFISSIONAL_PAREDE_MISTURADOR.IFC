Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_64.211_TORNEIRA_PROFISSIONAL_PAREDE_MISTURADOR.IFC
Time: 2023-05-03T18:43:04
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_64.211_TORNEIRA_PROFISSIONAL_PAREDE_MISTURADOR
In: Default Storey
Material: Steel
